Commit message: change object paths

File: urdf_collection/storage.urdf (robot description, URDF)
Before this commit: robot storage, 1 links, 0 joints
Links:
- link storage: geometry collision box size=0.0875 0.30 1.97; collision box size=0.0875 0.30 1.97
